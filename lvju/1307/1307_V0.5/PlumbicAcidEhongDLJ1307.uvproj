# Keil uVision project PlumbicAcidEhongDLJ1307.uvproj, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: GPM32F1307CL Generalplus
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0x01000000-0x0101DFFF) IROM2(0x02000000-0x02001FFF) CLOCK(8000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: PlumbicAcidEhongDLJ1307
  AfterMake: %KARM\Generalplus\Tools\KeilElfToBin\KeilElfToBin.exe "!L"  ".\Bins\%L.bin" "%KARM\Generalplus\Tools\KeilElfToBin\Body\$D.json" DISABLE
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=1
  c include: .\User\include;C:\keil_v5\ARM\PACK\Generalplus\GPM32F13xx_DFP\CMSIS\Include;C:\keil_v5\ARM\PACK\Generalplus\GPM32F13xx_DFP\Device\Include
  memory RVCT4: ROM 0x1000000 size 0x1e000
  memory RVCT5: ROM 0x2000000 size 0x2000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group Source
    ./User/source/: main.c init.c uart.c flash.c toolfun.c soc.c adcparam.c scheduler.c can.c userecord.c oneline.c trip.c
  group Include
    ./User/include/: main.h init.h flash.h hwparam.h toolfun.h soc.h type.h userfun.h can.h project.h
  group Libs
    ./Libs/: startup_gpm32f13xx.s system_gpm32f13xx.c PlumbicAcidEhongDLJ1307_250901_V0.1.lib
